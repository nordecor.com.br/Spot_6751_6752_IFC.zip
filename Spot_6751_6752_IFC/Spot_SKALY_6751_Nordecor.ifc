Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2025-04-18T18:50:13
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190327_2315(x64) - Exporter 20.0.0.377 - IU alternativa 20.0.0.377
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Apr 18 18:50:13 2025 * Host: MichellyManno * Database: C:\Users\MICHEL~1\AppData\Local\Temp\30e520c8-3d3c-4860-9b84-02a3e5e6c286\c27b88ed-c87e-4c78-99b4-6f06f7f7e490\ifc * Database version: 5507 * Database creation date: Fri Apr 18 18:50:11 2025 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Apr 18 18:50:12 2025 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Apr 18 18:50:12 2025 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Nome do projeto; Phase: Status do projeto

# IfcSite, Default
RefLatitude: -15, -52, 0, -120620; RefLongitude: -47, -55, 0, -114440; RefElevation: 0 mm
Outros - Categoria: Informações do projeto; Data de emissão do projeto: Data de emissão; Endereço do projeto: Insira aqui o endereço; Nome do cliente: Proprietário; Nome do projeto: Nome do projeto; Número do projeto: 0001; Status do projeto: Status do projeto

# IfcBuilding
Outros - Categoria: Informações do projeto; Data de emissão do projeto: Data de emissão; Endereço do projeto: Insira aqui o endereço; Nome do cliente: Proprietário; Nome do projeto: Nome do projeto; Número do projeto: 0001; Status do projeto: Status do projeto

# IfcBuildingStorey: Nível:Cabeça de 8 mm, Nível 1
LongName: Nível 1; Elevation: 0 mm
Restrições(Type) - Base da elevação: Ponto base do projeto
Outros(Type) - Categoria: Níveis; Nome da família: Nível
Cotas - Cálculo da altura: 0 mm
Dados de identidade - Andar da construção: yes; Estrutural: no; Nome: Nível 1
Outros - Categoria: Níveis; Família: Nível: Cabeça de 8 mm; Família e tipo: Nível: Cabeça de 8 mm; ID de tipo: Nível: Cabeça de 8 mm; Tipo: Nível: Cabeça de 8 mm
Restrições - Elevação: 0 mm
Dados de identidade(Type) - Nome do tipo: Cabeça de 8 mm
Gráficos(Type) - Cor: 0; Espessura da linha: 1; Padrão de linha: Centro (1); Símbolo: M_Cabeça do nível - Círculo: M_Cabeça do nível - Círculo; Símbolo no final 1 padrão: no; Símbolo no final 2 padrão: yes

# IfcFlowTerminal: 6751, Módulo_SKALY_6751_6752_Nordecor_IFC:6751:328317
In: Nível 1
Type - Material: Metal - Alumínio - Branco, LED, Plástico - PC - Transparente
Type - Cotas - Altura do Spot: 75 mm; Comprimento conector: 165 mm; Diâmetro do Spot: 47.4 mm
Type - Dados - Data de atualização: 18/04/2025; Versão: 1
Type - Dados de identidade - Contato do desenvolvedor: contato@checkbim.com.br; Contato do fabricante: comercial@nordecor.com.br; Descrição: Spot LED acabamento branco para trilho SKALY RAI dupla seção 6W 2700K 24º; Desenvolvedor: Check BIM; Fabricante: Nordecor; Garantia: 2 anos; IP: 20; Localização: Camboriú/SC - Brasil; Modelo: 6751; Nome do tipo: 6751; Número OmniClass: 23.80.70.11.14.21; Tipo de imagem: Imagem raster: 6751.png; Título OmniClass: Spots and Tracklight Specialties; URL: https://nordecor.com.br/; URL do desenvolvedor: https://checkbim.com.br/; URL do produto: https://nordecor.com.br/produto/spot-led-para-trilho-skaly-6w-2-700k/
Type - Elétrico - Comentários de voltagem: DC48V - 2 Seções; Lâmpada: LED
Type - Fotométricos - Ângulo de abertura: 24 deg; Fluxo luminoso: 520 lm; IRC: 97; Potência: 6 W; Temperatura de cor: 2700 K
Type - Gráficos - Simbologia: Imagem raster: 6751 2D.png
Type - Materiais e acabamentos - Difusor: Plástico - PC - Transparente; Spot: Metal - Alumínio - Branco
Type - Outros - Categoria: Luminárias; Branco: yes; Nome da família: Módulo_SKALY_6751_6752_Nordecor_IFC; Preto: no
Type - Restrições - Elevação-padrão: 1219.2 mm
Type - Visibilidade - 2D: yes
Cotas - Área: 0.0156277 m2; Volume: 0.000122652 m3
Dados de identidade - Marca: 1
Elétrico - Iluminação - Calcular coeficiente de utilização: no
Fase - Fase criada: Construção nova
Outros - Família: Módulo_SKALY_6751_6752_Nordecor_IFC: 6751; Família e tipo: Módulo_SKALY_6751_6752_Nordecor_IFC: 6751; ID de tipo: Módulo_SKALY_6751_6752_Nordecor_IFC: 6751; Tipo: Módulo_SKALY_6751_6752_Nordecor_IFC: 6751
Restrições - Elevação do nível: 0 mm; Hospedeiro: Nível : Nível 1; Nível: Nível: Nível 1; Nível de tabela: Nível: Nível 1
